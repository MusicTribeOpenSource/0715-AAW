# Keil uVision project bcr32_demo.uvprojx, settings and files
target BCR32_Demo (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: GD32F405RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bcr32_demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bincombined --bincombined_padding=1,0x00 --output .\Objects\bcr32_demo.bin !L
  AfterMake: ..\..\tools\update\generate_BCR.bat .\Objects\bcr32_demo.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F405 USE_STDPERIPH_DRIVER USE_USB_FS
  c misc: --diag_suppress 1296
  c include: ..\..\App;..\..\Board;..\..\Drivers\CMSIS;..\..\Drivers\GD32F4xx;..\..\ThirdParty\ssd1306;..\..\UsbDriver\core\Include;..\..\UsbDriver\driver\Include;..\..\UsbDriver\midi\inc
  asm misc: --cpreproc
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Board\bcr32_demo.sct
  group App
    ../../App/: main.c input.c sync_loop.c cv_out.c midi_thru.c activity_led.c flash_test.c iflash_test.c boot_jump.c sysex.c
  group Board
    ../../Board/: startup_bcr32.s bcr32_demo.sct bsp_gpio.c bsp_delay.c bsp_led.c bsp_buttons.c bsp_cv.c bsp_midi_uart.c bsp_spi1.c bsp_flash.c bsp_iflash.c bsp_usb.c
    ../../Drivers/GD32F4xx/: system_gd32f4xx.c
  group Drivers_GD32F4xx
    ../../Drivers/GD32F4xx/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_pmu.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_usart.c gd32f4xx_fmc.c
  group UsbDriver
    ../../UsbDriver/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
    ../../UsbDriver/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
    ../../UsbDriver/midi/src/: usbd_desc.c usbd_midi.c
  group ssd1306
    ../../ThirdParty/ssd1306/: ssd1306.c ssd1306_fonts.c
